EXTRA_OECONF:remove:class-target = " shared no-hw no-err no-psk no-srp no-ssl2 no-ssl3 no-rmd160 no-whirlpool no-rc2 no-rc4 no-bf no-cast no-gost"

