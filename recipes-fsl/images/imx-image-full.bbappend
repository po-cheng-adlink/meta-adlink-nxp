ROOTFS_POSTPROCESS_COMMAND:remove:lec-imx95 = "install_demo; "
